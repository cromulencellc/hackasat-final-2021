options:
  parameters:
    generate_options: no_gui
    id: payload_flatsat_rx
    output_language: python
    title: Payload Flatsat RX
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 901e6
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/num_chan*0.8
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: num_chan
  id: variable
  parameters:
    value: '18'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '15'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: rx_samp_rate_0
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-70'
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Received Data
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    alias: team_selector
    enabled: 'True'
    input_index: team_num-1
    num_inputs: '17'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: localhost
    mtu: '256'
    port: '2303'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: epy_block_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
      	def __init__(self, enabled=0):
      		gr.basic_block.__init__(
      			self,
      			name="Packet Counter",
      			in_sig=None,
      			out_sig=None)

      		self.message_port_register_in(pmt.intern('tx_in'))
      		self.message_port_register_in(pmt.intern('rx_in'))
      		
      		self.set_msg_handler(pmt.intern('tx_in'), self.tx)
      		self.set_msg_handler(pmt.intern('rx_in'), self.rx)
      		
      		self.tx_count = 0
      		self.rx_count = 0
      		self.enabled = enabled

      	def tx(self, msg):
      		if self.enabled:
      			self.tx_count += 1
      		else:
      			self.rx_count = 0
      			self.tx_count = 0
      	
      	def rx(self, msg):
      		if self.enabled and self.tx_count:
      			self.rx_count += 1	
      			print("Packets RX/TX: ",self.rx_count,"/",self.tx_count, " (",self.rx_count/self.tx_count*100,"%)",sep='')
    enabled: '1'
  states: {state: disabled}
- name: flatsat_rx_0
  id: flatsat_rx
  parameters:
    damping: '1'
    deviation: '1.5'
    timing_bw: '0.045'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[0,10,12,14,16,1,3,5,7,11,13,15,17,2,4,6,8,9]'
    comment: rx_sample_rate
    nchans: num_chan
    osr: '1'
    taps: lpf_taps
  states: {}
- name: rms_agc_0
  id: rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: team_num
  id: parameter
  parameters:
    label: Team Number Selector
    type: intx
    value: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: rx_samp_rate
    center_freq0: rx_freq
    dev_args: '""'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    sd_spec0: A:B
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', rms_agc_0, '0']
- [blocks_selector_0, '0', analog_pwr_squelch_xx_0, '0']
- [flatsat_rx_0, pdu, blocks_message_debug_0_0, print_pdu]
- [flatsat_rx_0, pdu, blocks_socket_pdu_1, pdus]
- [flatsat_rx_0, pdu, epy_block_0_0_0_0_0_0, rx_in]
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_selector_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_selector_0, '9']
- [pfb_channelizer_ccf_0, '11', blocks_selector_0, '10']
- [pfb_channelizer_ccf_0, '12', blocks_selector_0, '11']
- [pfb_channelizer_ccf_0, '13', blocks_selector_0, '12']
- [pfb_channelizer_ccf_0, '14', blocks_selector_0, '13']
- [pfb_channelizer_ccf_0, '15', blocks_selector_0, '14']
- [pfb_channelizer_ccf_0, '16', blocks_selector_0, '15']
- [pfb_channelizer_ccf_0, '17', blocks_selector_0, '16']
- [pfb_channelizer_ccf_0, '2', blocks_selector_0, '1']
- [pfb_channelizer_ccf_0, '3', blocks_selector_0, '2']
- [pfb_channelizer_ccf_0, '4', blocks_selector_0, '3']
- [pfb_channelizer_ccf_0, '5', blocks_selector_0, '4']
- [pfb_channelizer_ccf_0, '6', blocks_selector_0, '5']
- [pfb_channelizer_ccf_0, '7', blocks_selector_0, '6']
- [pfb_channelizer_ccf_0, '8', blocks_selector_0, '7']
- [pfb_channelizer_ccf_0, '9', blocks_selector_0, '8']
- [rms_agc_0, '0', flatsat_rx_0, '0']
- [uhd_usrp_source_0, '0', pfb_channelizer_ccf_0, '0']

metadata:
  file_format: 1
