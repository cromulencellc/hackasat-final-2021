options:
  parameters:
    author: spaceymcspaceface
    category: HAS
    generate_options: hb
    id: flatsat_rx
    output_language: python
    title: Flatsat RX
  states: {}

blocks:
- name: MTU
  id: variable
  parameters:
    value: '1500'
  states: {state: disabled}
- name: MTU
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    framebits: MTU*8
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: eb
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: preamble
  id: variable
  parameters:
    comment: 1acf fc1d
    value: '[0x1a, 0xcf, 0xfc, 0x1d, 0x1a, 0xcf, 0xfc, 0x1d, 0x1a, 0xcf, 0xfc, 0x1d, 0x1a, 0xcf, 0xfc, 0x1d]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {state: disabled}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*sps
    sym_rate: '1.0'
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(constel, False, sps, True, eb, False, False)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: constel
    modulus: constel.arity()
    step_size: '.0001'
    type: cma
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: 1/8
    lengthtagname: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_2
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: damping
  id: parameter
  parameters:
    label: Damping
    type: eng_float
    value: '1.0'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: Max Deviation
    type: eng_float
    value: '1.5'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.9999'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '"00011010110011111111110000011101"'
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: constel.arity()
    w: 6.28/200
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constel.arity()
  states: {}
- name: digital_linear_equalizer_0_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '1'
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: digital_map_bb_0_1
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_bw
    max_dev: deviation
    osps: '1'
    sps: sps
    taps: rx_rrc_taps
    type: ccf
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel
    damping: damping
    loop_bw: timing_bw
    max_dev: deviation
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Descramble Fixer",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.fix_pdu)
              
          def fix_pdu(self, msg):        
              pdu = pmt.to_python(msg)
              items = pdu[1]
              items = items[1:]
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(items), items))
              self.message_port_pub(pmt.intern('out'), pdu)
    comment: remove buffer byte that gets bugged by descrambler
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: dec
    mtu: MTU
    packed: 'True'
    rev_pack: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdu
    type: message
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: timing
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: equalizer
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0_0
  id: pad_sink
  parameters:
    label: costas
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0_0_0
  id: pad_sink
  parameters:
    label: bits
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_1_0_0_0_0
  id: pad_sink
  parameters:
    label: precrc
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_1_1
  id: pad_sink
  parameters:
    label: corr
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: timing_bw
  id: parameter
  parameters:
    label: Timing BW
    type: eng_float
    value: '0.045'
  states: {}

connections:
- [blocks_char_to_float_0_1, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_tagged_stream_to_pdu_2, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [blocks_tagged_stream_to_pdu_0, pdus, pad_sink_1_0_0_0_0, in]
- [blocks_tagged_stream_to_pdu_1, pdus, fec_async_decoder_0, in]
- [blocks_tagged_stream_to_pdu_2, pdus, epy_block_0_0_0, in]
- [blocks_unpack_k_bits_bb_0, '0', digital_descrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', pad_sink_1_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_corr_est_cc_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [digital_corr_est_cc_0, '1', pad_sink_1_1, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', digital_map_bb_0_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', pad_sink_1_0_0, '0']
- [digital_crc32_async_bb_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_descrambler_bb_0, '0', blocks_pack_k_bits_bb_1, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_linear_equalizer_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_linear_equalizer_0_0, '0', pad_sink_1_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_1, '0', blocks_char_to_float_0_1, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', pad_sink_1, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', pad_sink_1_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_linear_equalizer_0_0, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_1, '0']
- [digital_symbol_sync_xx_0, '0', pad_sink_1_0, '0']
- [epy_block_0_0_0, out, pad_sink_0, in]
- [fec_async_decoder_0, out, digital_crc32_async_bb_0, in]
- [fec_async_decoder_0, out, pad_sink_1_0_0_0_0, in]
- [pad_source_0, '0', digital_corr_est_cc_0, '0']
- [pad_source_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [pad_source_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
