options:
  parameters:
    author: spaceymcspaceface
    category: HAS
    generate_options: hb
    id: usersegment_tx
    output_language: python
    title: User Segment TX
  states: {}

blocks:
- name: MTU
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {state: disabled}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    framebits: MTU*8
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: eb
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: MTU*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {state: disabled}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    framebits: MTU*8
    ndim: '0'
    rep: rep
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: '"00011010110011111111110000011101"'
    bps: '1'
    threshold: '3'
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: add a buffer byte due to scrambler bug
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0x55]*1'
  states: {state: disabled}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0x0a]*1'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: eb
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, pattern=[0x55]*10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='HAS Idle Inserter',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.byte]
              )
              
              self.message_port_register_in(pmt.intern('pdu'))
              self.set_msg_handler(pmt.intern('pdu'), self.buffer_items)
              self.set_min_output_buffer(len(pattern))
              
              self.buffer = []
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.pattern = pattern

          def work(self, input_items, output_items):
              #print(self.pattern)
              #output_items[0][0:len(self.pattern)] = self.pattern
              output_items[0][:] = self.pattern
              numItems = len(output_items[0])
              #print("Output Len:",len(output_items[0]))
              
              if len(self.buffer)<numItems:
                  numItems = len(self.buffer)
              i = 0
              #print("Input/Output Size:", numItems,"/",len(output_items[0]))
              while i < numItems and numItems>0:
                  #pdu = pmt.to_python(self.pdu)
                  #data = pdu[1]
                  #print("PDU:",pdu)
                  #print("Data:",data)
                  #framesize = len(frame)
                  
                  output_items[0][i] = self.buffer[0]
                  self.buffer.pop(0)
                  i = i+1
                  #pmt.u8vector_ref(pdu, pmt.size(pdu)) → uint8_t
                  #self.pdu = None
              #print("Buffered items:",len(self.frames))
              	
              return len(output_items[0])

          def buffer_items(self, msg):
              pdu = pmt.to_python(msg)
              items = pdu[1]
              
              self.buffer.extend(items)
              #print("Buffer Len:",len(self.buffer))
    pattern: '[0x55]'
  states: {}
- name: fec_async_encoder_0_0
  id: fec_async_encoder
  parameters:
    encoder: enc
    mtu: MTU
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: iq
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: bytes
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: fec
    optional: 'True'
    type: message
  states: {state: disabled}
- name: pad_sink_1_0_0
  id: pad_sink
  parameters:
    label: tx_pdu
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pdu
    optional: 'True'
    type: message
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0_0, '1']
- [blocks_tagged_stream_mux_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', pad_sink_1, '0']
- [blocks_tagged_stream_mux_0_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, epy_block_0_1_0, pdu]
- [blocks_tagged_stream_to_pdu_0, pdus, pad_sink_1_0_0, in]
- [blocks_tagged_stream_to_pdu_1, pdus, digital_crc32_async_bb_1, in]
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_constellation_modulator_0, '0', pad_sink_0, '0']
- [digital_crc32_async_bb_1, out, fec_async_encoder_0_0, in]
- [digital_protocol_formatter_async_0, header, blocks_pdu_to_tagged_stream_0_0, pdus]
- [digital_protocol_formatter_async_0, payload, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [epy_block_0_1_0, '0', digital_constellation_modulator_0, '0']
- [fec_async_encoder_0_0, out, digital_protocol_formatter_async_0, in]
- [fec_async_encoder_0_0, out, pad_sink_1_0, in]
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0_1, pdus]

metadata:
  file_format: 1
