options:
  parameters:
    author: dev
    generate_options: qt_gui
    id: scrambler_loopback
    output_language: python
    title: Scrambler Loopback
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '8'
    minsize: '3'
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '256'
    port: '3001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_2
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0x0a]*1'
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self, enabled=1, payload=[0x55, 0x55]):
              gr.basic_block.__init__(
                  self,
                  name="Idle Packets",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_out(pmt.intern('pdus'))
              self.message_port_register_in(pmt.intern('trig'))
              self.set_msg_handler(pmt.intern('trig'), self.gen_pdu)
              
              self.payload = payload
              self.enabled = enabled
              
          def gen_pdu(self, msg):
          	if self.enabled:
                 pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(self.payload), self.payload))
                 self.message_port_pub(pmt.intern('pdus'), pdu)
    enabled: tx_0
    payload: '[0x55]*80'
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="Descramble Fixer",
                  in_sig=None,
                  out_sig=None)
              self.message_port_register_out(pmt.intern('out'))
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.fix_pdu)
              
          def fix_pdu(self, msg):        
              pdu = pmt.to_python(msg)
              items = pdu[1]
              items = items[1:]
              pdu = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(items), items))
              self.message_port_pub(pmt.intern('out'), pdu)
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, pattern=[0x55]*10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='HAS Idle Inserter',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.byte]
              )
              
              self.message_port_register_in(pmt.intern('pdu'))
              self.set_msg_handler(pmt.intern('pdu'), self.buffer_items)
              self.set_min_output_buffer(len(pattern))
              
              self.buffer = []
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.pattern = pattern

          def work(self, input_items, output_items):
              #print(self.pattern)
              #output_items[0][0:len(self.pattern)] = self.pattern
              output_items[0][:] = self.pattern
              numItems = len(output_items[0])
              #print("Output Len:",len(output_items[0]))
              
              if len(self.buffer)<numItems:
                  numItems = len(self.buffer)
              i = 0
              #print("Input/Output Size:", numItems,"/",len(output_items[0]))
              while i < numItems and numItems>0:
                  #pdu = pmt.to_python(self.pdu)
                  #data = pdu[1]
                  #print("PDU:",pdu)
                  #print("Data:",data)
                  #framesize = len(frame)
                  
                  output_items[0][i] = self.buffer[0]
                  self.buffer.pop(0)
                  i = i+1
                  #pmt.u8vector_ref(pdu, pmt.size(pdu)) → uint8_t
                  #self.pdu = None
              #print("Buffered items:",len(self.frames))
              	
              return len(output_items[0])

          def buffer_items(self, msg):
              pdu = pmt.to_python(msg)
              items = pdu[1]
              
              self.buffer.extend(items)
              #print("Buffer Len:",len(self.buffer))
    pattern: '[0x55]'
  states: {state: disabled}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_pack_k_bits_bb_1, '0', blocks_tagged_stream_to_pdu_2, '0']
- [blocks_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '0']
- [blocks_random_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_random_pdu_0, pdus, blocks_pdu_to_tagged_stream_0_1, pdus]
- [blocks_socket_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_socket_pdu_0, pdus, blocks_pdu_to_tagged_stream_0_1, pdus]
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [blocks_tagged_stream_mux_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_tagged_stream_to_pdu_2, pdus, epy_block_0_0_0, in]
- [blocks_unpack_k_bits_bb_0, '0', digital_scrambler_bb_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_pack_k_bits_bb_1, '0']
- [digital_scrambler_bb_0, '0', digital_descrambler_bb_0, '0']
- [epy_block_0_0_0, out, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
