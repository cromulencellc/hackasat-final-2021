options:
  parameters:
    author: dev
    generate_options: qt_gui
    id: usersegment_wideband_tx
    output_language: python
    title: User Segment Widebeband TX
  states: {}

blocks:
- name: MTU
  id: variable
  parameters:
    value: '256'
  states: {}
- name: chan_cutoff
  id: variable
  parameters:
    value: samp_rate/num_chan*0.8
  states: {}
- name: chan_samp_rate
  id: variable
  parameters:
    value: tx_samp_rate/(num_chan)
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    precision: '8'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: bpsk
  states: {}
- name: damping
  id: variable_qtgui_range
  parameters:
    label: Damping
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '1.0'
  states: {}
- name: deviation
  id: variable_qtgui_range
  parameters:
    label: Deviation
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '1.5'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '.22'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 901e6
  states: {}
- name: lpf_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, tx_samp_rate, chan_cutoff, 10e3, 300)
  states: {state: disabled}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/num_chan*0.8
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: num_chan
  id: variable
  parameters:
    value: '18'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: rx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 11,0,1,1
    label: RX Gain
    type: int
    value: '0'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: rx_samp_rate_0
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: rx_switch
  id: variable_qtgui_range
  parameters:
    gui_hint: 14,0,1,1
    label: RX On/Off
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: Power Squelch
    start: '-100'
    step: '1'
    stop: '0'
    value: '-70'
  states: {}
- name: strobe_delay
  id: variable_qtgui_entry
  parameters:
    label: Strobe Delay
    type: int
    value: '120'
  states: {state: disabled}
- name: strobe_delay
  id: variable_qtgui_range
  parameters:
    label: Strobe Delay
    rangeType: int
    start: '1'
    step: '1'
    stop: '1000'
    value: '1000'
  states: {}
- name: timing_bw
  id: variable_qtgui_range
  parameters:
    label: Timing BW
    start: '0.001'
    step: '0.001'
    stop: '0.1'
    value: '.045'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: freq
  states: {}
- name: tx_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 10,0,1,1
    label: TX Gain
    type: int
    value: '70'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: tx_samp_rate_0
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: Received Data
  states: {state: disabled}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters:
    comment: Received Data
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: strobe_delay
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    num_inputs: num_chan-2
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    num_outputs: num_chan-9
    type: complex
  states: {}
- name: blocks_null_source_0_0_0
  id: blocks_null_source
  parameters:
    num_outputs: '3'
    type: complex
  states: {state: disabled}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    comment: Random Payload Data
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '100'
    minsize: '100'
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3002'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3003'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_1
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3004'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_2
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3005'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_2_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3006'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_2_1
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3007'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_2_2
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: MTU
    port: '3008'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: TX Hardware Stand-In
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0000'
    freq_offset: '0.00067'
    noise_voltage: '0.0034'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: epy_block_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
      	def __init__(self, enabled=0):
      		gr.basic_block.__init__(
      			self,
      			name="Packet Counter",
      			in_sig=None,
      			out_sig=None)

      		self.message_port_register_in(pmt.intern('tx_in'))
      		self.message_port_register_in(pmt.intern('rx_in'))
      		
      		self.set_msg_handler(pmt.intern('tx_in'), self.tx)
      		self.set_msg_handler(pmt.intern('rx_in'), self.rx)
      		
      		self.tx_count = 0
      		self.rx_count = 0
      		self.enabled = enabled

      	def tx(self, msg):
      		if self.enabled:
      			self.tx_count += 1
      		else:
      			self.rx_count = 0
      			self.tx_count = 0
      	
      	def rx(self, msg):
      		if self.enabled and self.tx_count:
      			self.rx_count += 1	
      			print("Packets RX/TX: ",self.rx_count,"/",self.tx_count, " (",self.rx_count/self.tx_count*100,"%), Delta: ",self.tx_count-self.rx_count,sep='')
    enabled: '1'
  states: {}
- name: flatsat_rx_0
  id: flatsat_rx
  parameters:
    damping: damping
    deviation: deviation
    timing_bw: timing_bw
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[0,10,12,14,16,1,3,5,7,11,13,15,17,2,4,6,8,9]'
    comment: rx_sample_rate
    nchans: num_chan
    osr: '1'
    taps: lpf_taps
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    bus_conns: '[[0,],]'
    ch_map: '[0,10,12,14,16,1,3,5,7,11,13,15,17,2,4,6,8,9]'
    connections: num_chan
    numchans: num_chan
    taps: lpf_taps
    twox: 'False'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*32
    gui_hint: tab1@1
    name: Wideband RX
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: chan_samp_rate
    fc: '0'
    fftsize: 1024*4
    gui_hint: tab0@0
    name: AGC
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: chan_samp_rate
    fc: '0'
    fftsize: 1024*4
    gui_hint: tab0@2
    name: Timing
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: chan_samp_rate
    fc: '0'
    fftsize: 1024*4
    gui_hint: tab0@3
    name: Equalizer
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: chan_samp_rate
    fc: '0'
    fftsize: 1024*4
    gui_hint: tab0@4
    name: Costas
    plotwaterfall: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab1@0
    name: TX
    type: complex
  states: {}
- name: rms_agc_0
  id: rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,6,6,6
    label0: AGC
    label1: Correlation
    label2: Timing
    label3: Equalizer
    label4: Costas
    label5: Tab 5
    num_tabs: '6'
  states: {}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,6,6
    label0: TX
    label1: RX
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: tx_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: tx_samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: rx_samp_rate
    center_freq0: rx_freq
    dev_args: '""'
    gain0: rx_gain
    samp_rate: rx_samp_rate
    sd_spec0: A:B
    sync: pc_clock
    type: fc32
  states: {}
- name: usersegment_tx_0
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: usersegment_tx_0_0
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: usersegment_tx_0_0_0
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: usersegment_tx_0_0_0_0
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: usersegment_tx_0_0_0_0_0
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: usersegment_tx_0_0_0_0_1
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: usersegment_tx_0_0_0_0_2
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: usersegment_tx_0_0_0_0_3
  id: usersegment_tx
  parameters:
    maxoutbuf: '4096'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', rms_agc_0, '0']
- [blocks_message_strobe_0_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_null_source_0, '0', pfb_synthesizer_ccf_0, '0']
- [blocks_null_source_0_0, '0', pfb_synthesizer_ccf_0, '9']
- [blocks_null_source_0_0, '1', pfb_synthesizer_ccf_0, '10']
- [blocks_null_source_0_0, '2', pfb_synthesizer_ccf_0, '11']
- [blocks_null_source_0_0, '3', pfb_synthesizer_ccf_0, '12']
- [blocks_null_source_0_0, '4', pfb_synthesizer_ccf_0, '13']
- [blocks_null_source_0_0, '5', pfb_synthesizer_ccf_0, '14']
- [blocks_null_source_0_0, '6', pfb_synthesizer_ccf_0, '15']
- [blocks_null_source_0_0, '7', pfb_synthesizer_ccf_0, '16']
- [blocks_null_source_0_0, '8', pfb_synthesizer_ccf_0, '17']
- [blocks_random_pdu_0, pdus, epy_block_0_0_0_0_0_0, tx_in]
- [blocks_random_pdu_0, pdus, usersegment_tx_0, pdu]
- [blocks_socket_pdu_0, pdus, blocks_message_debug_0_0_0, print_pdu]
- [blocks_socket_pdu_0, pdus, epy_block_0_0_0_0_0_0, tx_in]
- [blocks_socket_pdu_0, pdus, usersegment_tx_0, pdu]
- [blocks_socket_pdu_0_0, pdus, usersegment_tx_0_0, pdu]
- [blocks_socket_pdu_0_0_0, pdus, usersegment_tx_0_0_0, pdu]
- [blocks_socket_pdu_0_0_1, pdus, usersegment_tx_0_0_0_0, pdu]
- [blocks_socket_pdu_0_0_2, pdus, usersegment_tx_0_0_0_0_0, pdu]
- [blocks_socket_pdu_0_0_2_0, pdus, usersegment_tx_0_0_0_0_1, pdu]
- [blocks_socket_pdu_0_0_2_1, pdus, usersegment_tx_0_0_0_0_2, pdu]
- [blocks_socket_pdu_0_0_2_2, pdus, usersegment_tx_0_0_0_0_3, pdu]
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [flatsat_rx_0, '0', qtgui_sink_x_0_0_0, '0']
- [flatsat_rx_0, '1', qtgui_sink_x_0_0_0_0, '0']
- [flatsat_rx_0, '2', qtgui_sink_x_0_0_0_0_1, '0']
- [flatsat_rx_0, pdu, blocks_message_debug_0_0, print_pdu]
- [flatsat_rx_0, pdu, epy_block_0_0_0_0_0_0, rx_in]
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', analog_pwr_squelch_xx_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_null_sink_0_0, '8']
- [pfb_channelizer_ccf_0, '11', blocks_null_sink_0_0, '9']
- [pfb_channelizer_ccf_0, '12', blocks_null_sink_0_0, '10']
- [pfb_channelizer_ccf_0, '13', blocks_null_sink_0_0, '11']
- [pfb_channelizer_ccf_0, '14', blocks_null_sink_0_0, '12']
- [pfb_channelizer_ccf_0, '15', blocks_null_sink_0_0, '13']
- [pfb_channelizer_ccf_0, '16', blocks_null_sink_0_0, '14']
- [pfb_channelizer_ccf_0, '17', blocks_null_sink_0_0, '15']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '3', blocks_null_sink_0_0, '1']
- [pfb_channelizer_ccf_0, '4', blocks_null_sink_0_0, '2']
- [pfb_channelizer_ccf_0, '5', blocks_null_sink_0_0, '3']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0_0, '4']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0_0, '5']
- [pfb_channelizer_ccf_0, '8', blocks_null_sink_0_0, '6']
- [pfb_channelizer_ccf_0, '9', blocks_null_sink_0_0, '7']
- [pfb_synthesizer_ccf_0, '0', virtual_sink_0, '0']
- [rms_agc_0, '0', flatsat_rx_0, '0']
- [rms_agc_0, '0', qtgui_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', virtual_sink_1, '0']
- [usersegment_tx_0, '0', pfb_synthesizer_ccf_0, '1']
- [usersegment_tx_0, tx_pdu, blocks_message_debug_0_0_0, print_pdu]
- [usersegment_tx_0_0, '0', pfb_synthesizer_ccf_0, '2']
- [usersegment_tx_0_0_0, '0', pfb_synthesizer_ccf_0, '3']
- [usersegment_tx_0_0_0_0, '0', pfb_synthesizer_ccf_0, '4']
- [usersegment_tx_0_0_0_0_0, '0', pfb_synthesizer_ccf_0, '5']
- [usersegment_tx_0_0_0_0_1, '0', pfb_synthesizer_ccf_0, '6']
- [usersegment_tx_0_0_0_0_2, '0', pfb_synthesizer_ccf_0, '7']
- [usersegment_tx_0_0_0_0_3, '0', pfb_synthesizer_ccf_0, '8']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0_0, '0', pfb_channelizer_ccf_0, '0']
- [virtual_source_0_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
